# IAR project STM32_LwIP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\CMSIS; ..\StdPeriph_Driver\inc; ..\User; ..\lwip-1.4.1; ..\lwip-1.4.1\src\include; ..\lwip-1.4.1\src\include\ipv4; ..\lwip-1.4.1\arch; ..\lwip-1.4.1\src\include\lwip; ..\lwip-1.4.1\src\include\netif; ..\lwip-1.4.1\src\netif
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32_LwIP.srec
  ILINK.IlinkOutputFile: STM32-uIP.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/: core_cm3.c stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group LwIP
    ../lwip-1.4.1/: lwipopts.h
  group LwIP/src/core
    ../lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LwIP/src/core/ipv4
    ../lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP/src/netif
    ../lwip-1.4.1/src/netif/: etharp.c ethernetif.c ethernetif.h
  group StartUp
    ../StartUp/: startup_stm32f10x_hd.s
  group Stdperiph_Driver
    ../StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group User
    ../User/: bsp_spi1.c bsp_spi1.h bsp_usart.c bsp_usart.h echo.c echo.h enc28j60.c enc28j60.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h timer.c timer.h
